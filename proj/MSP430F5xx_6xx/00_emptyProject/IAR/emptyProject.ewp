# IAR project emptyProject.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsff.h
  General.OGChipSelectMenu: MSP430F5529 MSP430F5529
  General.GStackSize2: 200
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: __MSP430_HAS_PORT7_R__; __MSP430_HAS_PORT8_R__; __MSP430_HAS_PORTD_R__; __MSP430F5529__
  ICC430.newCCIncludePaths: ..\..\..\..\driverlib\MSP430F5xx_6xx; ..\..\..\..\driverlib\\00_emptyProject; ..\..\..\..\proj\MSP430F5xx_6xx\00_emptyProject\inc
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f5529.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: DEPRECATED
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group driverlib/MSP430F5xx_6xx
    ../../../../driverlib/MSP430F5xx_6xx/: adc10_a.c adc10_a.h adc12_a.c adc12_a.h aes.c aes.h battbak.c battbak.h comp_b.c comp_b.h crc.c crc.h dac12_a.c dac12_a.h dma.c dma.h driverlib.h eusci_a_spi.c eusci_a_spi.h eusci_a_uart.c eusci_a_uart.h eusci_b_i2c.c eusci_b_i2c.h eusci_b_spi.c eusci_b_spi.h flashctl.c flashctl.h gpio.c gpio.h ldopwr.c ldopwr.h mpy32.c mpy32.h pmap.c pmap.h pmm.c pmm.h ram.c ram.h ref.c ref.h rtc_a.c rtc_a.h rtc_b.c rtc_b.h rtc_c.c rtc_c.h sd24_b.c sd24_b.h sfr.c sfr.h sysctl.c sysctl.h tec.c tec.h timer_a.c timer_a.h timer_b.c timer_b.h timer_d.c timer_d.h tlv.c tlv.h ucs.c ucs.h usci_a_spi.c usci_a_spi.h usci_a_uart.c usci_a_uart.h usci_b_i2c.c usci_b_i2c.h usci_b_spi.c usci_b_spi.h wdt_a.c wdt_a.h
  group driverlib/MSP430F5xx_6xx/inc
    ../../../../driverlib/MSP430F5xx_6xx/inc/: hw_memmap.h version.h
  group src
    ../src/: LCD12864P.c main.c User_ADC.c User_I2C.c User_timer.c
    ../inc/: User_ADC.h User_I2C.h
